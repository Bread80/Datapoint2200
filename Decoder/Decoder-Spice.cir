.title KiCad schematic
C5 GND +5V .1u
C15 +5V GND 6V47u
C4 +5V GND 6V47u
C6 GND +5V .1u
C8 +5V GND 6V47u
C7 GND +5V .1u
C11 GND +5V .1u
C9 +5V GND 6V47u
C12 GND +5V .1u
C14 GND +5V .1u
C26 GND +5V .1u
C16 +5V GND .1
C20 +5V GND 6V47u
C24 +5V GND .1u
C13 +5V GND .1u
C19 +5V GND .1u
C17 +5V GND .1u
C25 +5V GND .1u
J4A1 GND NC_01 STROBE_3 PHASE_CLK ~DIV64_CLK PHI1_REG PHI1_MEM STROBE_4 STROBE_1 ~T1 220_R2 DECK_1 1.5KC SPEAKER 7.5CPS ~READ_BLK_STB ~WRITE_EOF_STB I1 I2 I3 I4 ~ENABLE_2 ~BACK_SPACE_STB ~SLEW_FWB_STB ~SLEW_REV_STB ~RWD_STB ~T_STOP_STB GND EdgeTop
J4B1 +5V NC_02 BEEP NC_03 DIV64_CLK 1.2MHz PHI2_MEM STROBE_2 EN_COMP INH_MEM INT_FACE_CLK 220_R1 REWIND ~ADDRESS ~POR ~DECK_1_STB ~WRITE_BLK_STB ~DECK_2_STB ~SENSE_DATA_STB ~SENSE_STATUS_STB ~ADR_STB ~ENABLE_1 ~COM_4 ~WRITE_STB ~COM_1 ~COM_2 ~COM_3 +5V EdgeBottom
H902 MountingHole
H903 MountingHole
H904 MountingHole
H901 MountingHole
H907 MountingHole
H908 MountingHole
Y1 GND Net-_C1-Pad1_ 9.8400MHz
C1 Net-_C1-Pad1_ Net-_C1-Pad2_ 160p
C2 Net-_C1-Pad2_ GND 160p
R1 Net-_C1-Pad1_ Net-_C1-Pad2_ 1k5
R2 Net-_C3-Pad2_ Net-_C1-Pad1_ 2k2
Q1 Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_C3-Pad2_ 2N2369A
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 51p
R3 Net-_C3-Pad1_ Net-_C3-Pad2_ 1k
R4 +5V Net-_C3-Pad2_ 560
R5 9.84MHz +5V 1k
R6 GND Net-_C3-Pad1_ 1k
L1 Net-_C1-Pad2_ GND 120uH 75mA
Q2 GND Net-_C3-Pad1_ 9.84MHz 2N2369A
Z11 Net-_Z11-Pad1_ +5V +5V /Scheduler/~STEP8or9_T2 NC_04 STROBE_3 GND PHASE_CLK Net-_Z11-Pad9_ +5V SYS_CLK PHASE_CLK +5V +5V 7474
Z16 +5V Net-_Z16-Pad2_ Net-_Z11-Pad9_ +5V Net-_Z16-Pad5_ Net-_Z16-Pad12_ GND Net-_Z16-Pad8_ Net-_Z16-Pad2_ +5V Net-_Z11-Pad9_ Net-_Z16-Pad12_ +5V +5V 7474
Z6 T2 Net-_Z16-Pad8_ Net-_Z16-Pad5_ T0 Net-_Z16-Pad2_ Net-_Z16-Pad12_ GND Net-_Z16-Pad5_ Net-_Z16-Pad2_ T1 Net-_Z16-Pad8_ Net-_Z16-Pad12_ T3 +5V 7402
Z18 Net-_Z18-Pad1_ GND GND +5V INT_FACE_CLK NC_05 GND NC_06 Net-_Z18-Pad1_ T1 7493
R28 INT_FACE_CLK +5V 470
Z13 +5V NC_07 C3 ~DIV64_CLK T0 /Scheduler/~T0 GND Net-_Z13-Pad8_ DECK_1 Net-_Z13-Pad10_ I2 Net-_Z13-Pad12_ I4 +5V 7404
Z2 C0 GND GND +5V GND GND C2 C1 GND C3 C0 /Scheduler/~T0 7490
Z12 T1 1.2MHz Net-_Z12-Pad3_ PHI1_REG Net-_Z12-Pad3_ PHI1_REG GND /Scheduler/~T3 T3 Net-_Z12-Pad10_ C0 ~T1 T1 +5V 7404
Z19 STROBE_4 ~STEP9 /Scheduler/~T3 STROBE_2 ~T1 ~STEP9 GND /Scheduler/~C0 ~T1 EN_COMP /Scheduler/~T3 /Scheduler/~STEP8 STROBE_1 +5V 7402
Z8 PHASE_CLK T0 Net-_Z17-Pad1_ /Scheduler/~C0 ~STEP9 /Scheduler/STEPS1TO8 GND Net-_Z21-Pad19_ Net-_Z5-Pad8_ ~ADDRESS Net-_C10-Pad1_ Net-_C10-Pad2_ Net-_C10-Pad2_ +5V 7408
Z3 NC_08 +5V +5V Net-_Z3-Pad4_ C2 C3 GND C3 INH_MEM Net-_Z17-Pad10_ C1 C0 Net-_Z3-Pad13_ +5V 7402
Z7 ~DIV64_CLK /Scheduler/~T0 Net-_Z11-Pad1_ C3 T2 /Scheduler/~STEP8or9_T2 GND ~STEP9 C3 C0 /Scheduler/~C0 Net-_Z3-Pad13_ Net-_Z3-Pad4_ +5V 7400
Z17 Net-_Z17-Pad1_ /Scheduler/STEPS1TO8 Net-_Z12-Pad3_ T1 Net-_Z17-Pad10_ PHI2_MEM GND PHI1_MEM T3 Net-_Z17-Pad10_ /Scheduler/~STEP8 C3 Net-_Z12-Pad10_ +5V 7400
Z15 ~SENSE_DATA ~SENSE_DATA_STB ~SENSE_STATUS ~SENSE_STATUS_STB ~SLEW_REV ~SLEW_REV_STB GND ~T_STOP_STB ~T_STOP ~RWD_STB ~RWD DIV64_CLK C3 +5V 7407
JP901 9.84MHz SYS_CLK RP_CLK CLK SRC
H905 MountingHole
H906 MountingHole
U901 +5V C0 C1 C2 C3 T3 T2 T1 T0 GND /Scheduler/StampClock/T0 /Scheduler/StampClock/T1 /Scheduler/StampClock/T2 /Scheduler/StampClock/T3 /Scheduler/StampClock/C3 /Scheduler/StampClock/C2 /Scheduler/StampClock/C1 /Scheduler/StampClock/C0 GND +5V 74HCT245
U902 +5V PHI2_MEM PHI1_MEM STROBE_1 EN_COMP STROBE_3 STROBE_4 STROBE_2 INT_FACE_CLK GND Net-_R921-Pad2_ Net-_R920-Pad2_ Net-_R919-Pad2_ Net-_R918-Pad2_ Net-_R917-Pad2_ Net-_R916-Pad2_ Net-_R915-Pad2_ Net-_R914-Pad2_ GND +5V 74HCT245
R901 Net-_Q901-Pad3_ Net-_D901-Pad1_ 470
R909 Net-_Q902-Pad3_ Net-_D909-Pad1_ 470
R908 Net-_D908-Pad2_ /Scheduler/StampClock/T0 470
R911 Net-_D911-Pad2_ /Scheduler/StampClock/T1 470
R907 Net-_D907-Pad2_ /Scheduler/StampClock/T2 470
R906 Net-_D906-Pad2_ /Scheduler/StampClock/T3 470
R902 Net-_D902-Pad2_ /Scheduler/StampClock/C3 470
R904 Net-_D904-Pad2_ /Scheduler/StampClock/C2 470
R905 Net-_D905-Pad2_ /Scheduler/StampClock/C1 470
R903 Net-_D903-Pad2_ /Scheduler/StampClock/C0 470
R912 Net-_Q904-Pad3_ Net-_D912-Pad1_ 470
R915 Net-_D915-Pad2_ Net-_R915-Pad2_ 470
R914 Net-_D914-Pad2_ Net-_R914-Pad2_ 470
R910 Net-_Q903-Pad3_ Net-_D910-Pad1_ 470
R913 Net-_Q905-Pad3_ Net-_D913-Pad1_ 470
R917 Net-_D917-Pad2_ Net-_R917-Pad2_ 470
R916 Net-_D916-Pad2_ Net-_R916-Pad2_ 470
R920 Net-_D920-Pad2_ Net-_R920-Pad2_ 470
R918 Net-_D918-Pad2_ Net-_R918-Pad2_ 470
R919 Net-_D919-Pad2_ Net-_R919-Pad2_ 470
R921 Net-_D921-Pad2_ Net-_R921-Pad2_ 470
D901 Net-_D901-Pad1_ +5V 9.84MHz
D909 Net-_D909-Pad1_ +5V PHASE_CLK
D908 GND Net-_D908-Pad2_ T0
D911 GND Net-_D911-Pad2_ T1
D907 GND Net-_D907-Pad2_ T2
D906 GND Net-_D906-Pad2_ T3
D902 GND Net-_D902-Pad2_ C3
D904 GND Net-_D904-Pad2_ C2
D905 GND Net-_D905-Pad2_ C1
D903 GND Net-_D903-Pad2_ C0
D912 Net-_D912-Pad1_ +5V INH_MEM
D913 Net-_D913-Pad1_ +5V DIV64_CLK
D915 GND Net-_D915-Pad2_ PHI1_MEM
D914 GND Net-_D914-Pad2_ PHI2_MEM
D917 GND Net-_D917-Pad2_ EN_COMP
D910 Net-_D910-Pad1_ +5V PHI1_REG
D916 GND Net-_D916-Pad2_ STROBE1
D920 GND Net-_D920-Pad2_ STROBE2
D918 GND Net-_D918-Pad2_ STROBE3
D919 GND Net-_D919-Pad2_ STROBE4
D921 GND Net-_D921-Pad2_ INT_FACE_CLK
Q901 SYS_CLK GND Net-_Q901-Pad3_ 2N7002
Q902 PHASE_CLK GND Net-_Q902-Pad3_ 2N7002
Q903 PHI1_REG GND Net-_Q903-Pad3_ 2N7002
Q904 INH_MEM GND Net-_Q904-Pad3_ 2N7002
Q905 C3 GND Net-_Q905-Pad3_ 2N7002
U981 NC_09 NC_10 NC_11 NC_12 NC_13 NC_14 NC_15 NC_16 NC_17 WORD_SELECT RP_CLK NC_18 Net-_U981-Pad13_ Net-_U981-Pad14_ Net-_U981-Pad15_ Net-_U981-Pad16_ Net-_U981-Pad17_ Net-_U981-Pad18_ Net-_U981-Pad19_ Net-_U981-Pad20_ NC_19 NC_20 NC_21 NC_22 NC_23 NC_24 NC_25 Net-_SW982-Pad2_ Net-_SW983-Pad2_ Net-_SW984-Pad2_ GND NC_26 +5V +3V3 Net-_J981-Pad2_ Net-_J981-Pad3_ NC_27 NC_28 NC_29 Net-_SW981-Pad2_ RP2040_Stamp
J981 NC_30 Net-_J981-Pad2_ Net-_J981-Pad3_ GND GND USB_B
SW982 GND Net-_SW982-Pad2_ RUN STOP
SW983 GND Net-_SW983-Pad2_ +/T
U982 +5V /Scheduler/StampClock/C3 /Scheduler/StampClock/C2 /Scheduler/StampClock/C1 /Scheduler/StampClock/C0 /Scheduler/StampClock/T3 /Scheduler/StampClock/T2 /Scheduler/StampClock/T1 /Scheduler/StampClock/T0 GND Net-_U981-Pad20_ Net-_U981-Pad19_ Net-_U981-Pad18_ Net-_U981-Pad17_ Net-_U981-Pad16_ Net-_U981-Pad15_ Net-_U981-Pad14_ Net-_U981-Pad13_ GND +3V3 74LVC245
SW984 GND Net-_SW984-Pad2_ -/S
SW981 GND Net-_SW981-Pad2_ BOOTSEL
Q906 Net-_J902-Pad1_ GND WORD_SELECT 2N7002
J902 Net-_J902-Pad1_ ~WORD_SELECT
Z14 NC_31 NC_32 NC_33 NC_34 NC_35 NC_36 NC_37 NC_38 ~ADR ~SENSE_STATUS ~SENSE_DATA GND ~WRITE ~COM1 ~COM2 ~COM3 ~COM4 ~ENABLE_1 ~ENABLE_1 I4 I3 I2 I1 +5V 74154
Z10 ~COM3 ~COM_3 ~COM2 ~COM_2 ~COM1 ~COM_1 GND ~ADR_STB ~ADR ~COM_4 ~COM4 ~WRITE_STB ~WRITE +5V 7407
R12 +5V ~COM_4 470
R16 +5V ~COM_3 470
R15 +5V ~COM_2 470
R14 +5V ~COM_1 470
R13 +5V ~WRITE_STB 470
R17 +5V ~SENSE_DATA_STB 470
R18 +5V ~SENSE_STATUS_STB 470
R11 +5V ~ADR_STB 470
Z22 ~BACK_SPACE ~BACK_SPACE_STB ~DECK_1 ~DECK_1_STB ~READ_BLK ~READ_BLK_STB GND ~DECK_2_STB ~DECK_2 ~WRITE_BLK_STB ~WRITE_BLK ~SLEW_FWB_STB ~SLEW_FWB +5V 7407
Z21 ~PORT0 ~PORT1 ~PORT2 ~PORT3 /IODecoder/~BEEP /IODecoder/~CLICK ~DECK_1 ~DECK_2 ~READ_BLK ~WRITE_BLK ~WRITE_EOF_STB GND ~BACK_SPACE ~SLEW_FWB ~SLEW_REV ~RWD ~T_STOP ~ENABLE_2 Net-_Z21-Pad19_ I4 I3 I2 I1 +5V 74154
R19 +5V ~T_STOP_STB 2k2
R20 +5V ~RWD_STB 2k2
R21 +5V ~SLEW_REV_STB 2k2
R22 +5V ~SLEW_FWB_STB 2k2
R23 +5V ~BACK_SPACE_STB 2k2
R26 +5V ~WRITE_BLK_STB 2k2
R24 +5V ~READ_BLK_STB 2k2
R27 +5V ~DECK_2_STB 2k2
R25 +5V ~DECK_1_STB 2k2
Z5 ~POR Net-_Z1-Pad2_ Net-_Z1-Pad8_ ~POR Net-_Z1-Pad12_ Net-_Z5-Pad6_ GND Net-_Z5-Pad8_ I3 Net-_Z13-Pad10_ Net-_Z13-Pad12_ Net-_Z5-Pad12_ Net-_Z1-Pad6_ +5V 7410
U944 ~ADR Net-_R957-Pad2_ ~COM4 Net-_R964-Pad2_ ~WRITE Net-_R960-Pad2_ GND Net-_R963-Pad2_ ~COM3 Net-_R962-Pad2_ ~COM2 Net-_R961-Pad2_ ~COM1 +5V 74LS04
U943 ~T_STOP Net-_R956-Pad2_ ~RWD Net-_R955-Pad2_ ~SLEW_REV Net-_R954-Pad2_ GND Net-_R959-Pad2_ ~SENSE_DATA Net-_R958-Pad2_ ~SENSE_STATUS Net-_R951-Pad2_ ~WRITE_EOF_STB +5V 74LS04
U941 ~PORT0 Net-_R941-Pad2_ ~PORT1 Net-_R942-Pad2_ ~PORT2 Net-_R943-Pad2_ GND Net-_R944-Pad2_ ~PORT3 Net-_R946-Pad2_ /IODecoder/~CLICK Net-_R945-Pad2_ /IODecoder/~BEEP +5V 74LS04
U942 ~WRITE_BLK Net-_R950-Pad2_ ~DECK_1 Net-_R947-Pad2_ ~SLEW_FWB Net-_R953-Pad2_ GND Net-_R952-Pad2_ ~BACK_SPACE Net-_R949-Pad2_ ~READ_BLK Net-_R948-Pad2_ ~DECK_2 +5V 74LS04
R957 Net-_D957-Pad2_ Net-_R957-Pad2_ 470
R958 Net-_D958-Pad2_ Net-_R958-Pad2_ 470
R959 Net-_D959-Pad2_ Net-_R959-Pad2_ 470
R960 Net-_D960-Pad2_ Net-_R960-Pad2_ 470
R961 Net-_D961-Pad2_ Net-_R961-Pad2_ 470
R962 Net-_D962-Pad2_ Net-_R962-Pad2_ 470
R963 Net-_D963-Pad2_ Net-_R963-Pad2_ 470
R964 Net-_D964-Pad2_ Net-_R964-Pad2_ 470
R941 Net-_D941-Pad2_ Net-_R941-Pad2_ 470
R942 Net-_D942-Pad2_ Net-_R942-Pad2_ 470
R943 Net-_D943-Pad2_ Net-_R943-Pad2_ 470
R944 Net-_D944-Pad2_ Net-_R944-Pad2_ 470
R945 Net-_D945-Pad2_ Net-_R945-Pad2_ 470
R946 Net-_D946-Pad2_ Net-_R946-Pad2_ 470
R947 Net-_D947-Pad2_ Net-_R947-Pad2_ 470
R948 Net-_D948-Pad2_ Net-_R948-Pad2_ 470
R956 Net-_D956-Pad2_ Net-_R956-Pad2_ 470
R955 Net-_D955-Pad2_ Net-_R955-Pad2_ 470
R954 Net-_D954-Pad2_ Net-_R954-Pad2_ 470
R953 Net-_D953-Pad2_ Net-_R953-Pad2_ 470
R952 Net-_D952-Pad2_ Net-_R952-Pad2_ 470
R951 Net-_D951-Pad2_ Net-_R951-Pad2_ 470
R950 Net-_D950-Pad2_ Net-_R950-Pad2_ 470
R949 Net-_D949-Pad2_ Net-_R949-Pad2_ 470
D957 GND Net-_D957-Pad2_ ADDR
D958 GND Net-_D958-Pad2_ STATUS
D959 GND Net-_D959-Pad2_ DATA
D960 GND Net-_D960-Pad2_ WRITE
D961 GND Net-_D961-Pad2_ COM1
D962 GND Net-_D962-Pad2_ COM2
D963 GND Net-_D963-Pad2_ COM3
D964 GND Net-_D964-Pad2_ COM4
D956 GND Net-_D956-Pad2_ T_STOP
D955 GND Net-_D955-Pad2_ REWIND
D954 GND Net-_D954-Pad2_ SLEWBCK
D953 GND Net-_D953-Pad2_ SLEWFWD
D952 GND Net-_D952-Pad2_ BACKSP
D951 GND Net-_D951-Pad2_ WR_EOF
D950 GND Net-_D950-Pad2_ WR_BLK
D949 GND Net-_D949-Pad2_ RD_BLK
D948 GND Net-_D948-Pad2_ DECK2
D947 GND Net-_D947-Pad2_ DECK1
D946 GND Net-_D946-Pad2_ CLICK
D945 GND Net-_D945-Pad2_ BEEP
D944 GND Net-_D944-Pad2_ PORT3
D943 GND Net-_D943-Pad2_ PORT2
D942 GND Net-_D942-Pad2_ PORT1
D941 GND Net-_D941-Pad2_ PORT0
Z9 Net-_Z5-Pad6_ /IODecoder/~CLICK Net-_Z1-Pad12_ Net-_Z5-Pad12_ /IODecoder/~BEEP Net-_Z1-Pad2_ GND BEEP Net-_Z1-Pad9_ Net-_Z1-Pad9_ Net-_Z4-Pad6_ Net-_Z1-Pad5_ Net-_C10-Pad1_ +5V 7400
Z1 ~POR Net-_Z1-Pad2_ 7.5CPS +5V Net-_Z1-Pad5_ Net-_Z1-Pad6_ GND Net-_Z1-Pad8_ Net-_Z1-Pad9_ +5V Net-_C10-Pad1_ Net-_Z1-Pad12_ ~POR +5V 7474
C21 GND 7.5CPS .001u 200V
C22 ~POR +5V .001u 200V
C10 Net-_C10-Pad1_ Net-_C10-Pad2_ .01u 50V
R10 Net-_C10-Pad1_ Net-_C10-Pad2_ 10k
CR2 +5V Net-_C10-Pad2_ 1N914
C23 +5V Net-_C10-Pad2_ .001u 200V
CR1 Net-_C10-Pad2_ GND 1N914
R9 1.5KC Net-_C10-Pad2_ 2k2
R7 /Speaker_Tape/SP1 SPEAKER 5.1
R8 /Speaker_Tape/SP2 SPEAKER 1.2
Z4 BEEP BEEP /Speaker_Tape/SP2 GND /Speaker_Tape/SP1 Net-_Z4-Pad6_ Net-_Z4-Pad6_ +5V 75451
Z20 Net-_Z13-Pad8_ REWIND 220_R2 GND 220_R1 DECK_1 REWIND +5V 75451
.end
